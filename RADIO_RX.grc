options:
  parameters:
    author: ardiu
    generate_options: qt_gui
    id: opus2
    output_language: python
    title: O 2
  states: {}

blocks:
- name: cma_algo
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '1'
    step_size: '.0001'
    type: cma
  states: {}
- name: decoder
  id: variable_cc_decoder_def
  parameters:
    framebits: '1280'
    k: '7'
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: samp_rate_2
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '20'
    rate: '0.005e-3'
    reference: '1'
    type: complex
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    comment: Audio Player
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_matrix_interleaver_0_0
  id: blocks_matrix_interleaver
  parameters:
    cols: '80'
    comment: |-
      Deinterleaver:
      Obtain a Memoryless Channel
    deint: 'True'
    rows: '32'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Bits to Byte
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_unpack_k_bits_bb_0_2
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Byte to Bits
    k: '8'
  states: {}
- name: digital_additive_scrambler_xx_1
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '3'
    count: '0'
    len: '8'
    mask: '0x8A'
    reset_tag_key: '""'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0_1
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '55'
    rolloff: '0.350'
    samps_per_sym: sps
    type: cc
    w: '0.005'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: cma_algo
    comment: 'Equalizer:'
    num_taps: '2'
    sps: '1'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    comment: Soft Bits
    map: '[-1,1]'
  states: {}
- name: digital_map_bb_0_0_1
  id: digital_map_bb
  parameters:
    comment: Gray coding
    map: '[0,1,3,2]'
  states: {}
- name: digital_symbol_sync_xx_0_1
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1'
    loop_bw: '0.01'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '2.7'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import opuslib

      class opus_decoder_stream(gr.basic_block):
          def __init__(self, sample_rate=48000):
              gr.basic_block.__init__(self, name='Opus Decoder Stream',
                                      in_sig=[np.uint8], out_sig=[np.float32])
              
              self.sample_rate = sample_rate
              self.frame_size = 960 
              self.dec = opuslib.Decoder(sample_rate, 1)

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # 1. Scan for Sync Word (0xAA 0x55)
              sync_idx = -1
              for i in range(len(in0) - 1):
                  if in0[i] == 0xAA and in0[i+1] == 0x55:
                      sync_idx = i
                      break

              if sync_idx == -1:
                  # Sync not found. Consume everything except the last byte 
                  # (in case it is 0xAA and the 0x55 is in the next buffer)
                  consume_len = max(0, len(in0) - 1)
                  if consume_len > 0:
                      self.consume(0, consume_len)
                  return 0

              # 2. If sync word isn't at the very beginning, consume the garbage before it
              if sync_idx > 0:
                  self.consume(0, sync_idx)
                  return 0 # Return to realign the buffer on the next call

              # 3. Read Length Header
              if len(in0) < 4:
                  return 0 # Wait for length bytes
                  
              packet_len = (int(in0[2]) << 8) | int(in0[3])
              total_len = packet_len + 4
              
              # 4. Wait for full packet and output space
              if len(in0) < total_len:
                  return 0 
                  
              if len(out) < self.frame_size:
                  return 0 
                  
              packet_data = bytes(in0[4:total_len])
              
              try:
                  # 5. Decode Audio
                  decoded_pcm = self.dec.decode(packet_data, self.frame_size)
                  floats = np.frombuffer(decoded_pcm, dtype=np.int16).astype(np.float32) / 32767.0
                  
                  out[:self.frame_size] = floats
                  self.consume(0, total_len)
                  return self.frame_size
                  
              except Exception as e:
                  # Decode failed (could be a false sync word or corrupted payload).
                  # Consume the 0xAA 0x55 so we don't get stuck in an infinite loop, and resume searching.
                  self.consume(0, 2)
                  return 0
    comment: |-
      Source Decoder:
      Opus
    sample_rate: '48000'
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class rsa_decrypt_byte(gr.sync_block):
          def __init__(self, private_d=63, n=253):
              gr.sync_block.__init__(
                  self,
                  name='RSA Decryption',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.d = private_d
              self.n = n

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # RSA Decryption: m = (c^d) % n
              for i in range(len(in0)):
                  out[i] = pow(int(in0[i]), self.d, self.n)
                  
              return len(output_items[0])
    comment: |-
      Decryption:
      Rivest-Shamir-Adleman
    n: '253'
    private_d: '153'
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: decoder
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: filter_fft_rrc_filter_0_0_1
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    comment: |-
      Symbol Rate: samp_rate/sps
      Alpha: excess_bw
      Num Taps: 11*sps
    decim: '1'
    gain: '1'
    ntaps: sps*25
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: iio_pluto_source_0_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '16384'
    filter_source: '''Auto'''
    frequency: '868300000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 'usb:'
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: Receiver
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    alpha2: '1'
    grid: 'True'
    gui_hint: 2,0,10,10
    label1: Synced Only
    label2: Synced & Phase-Locked
    name: Synced Constellation
    nconnections: '2'
    size: '1024'
    type: complex
    width2: '2'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_eye_sink_x_0_1
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    style1: '3'
    type: complex
  states: {}
- name: virtual_sink_1_2
  id: virtual_sink
  parameters:
    stream_id: received_data
  states: {}
- name: virtual_sink_1_2_0_1
  id: virtual_sink
  parameters:
    stream_id: unpacked_data
  states: {}
- name: virtual_sink_1_2_1
  id: virtual_sink
  parameters:
    stream_id: received_symbol
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: received_symbol
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: received_data
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: unpacked_data
  states: {}

connections:
- [analog_agc_xx_0_0, '0', digital_fll_band_edge_cc_0_0, '0']
- [blocks_char_to_float_0_0, '0', fec_extended_decoder_0_0, '0']
- [blocks_matrix_interleaver_0_0, '0', digital_map_bb_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', digital_additive_scrambler_xx_1, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_1, '0']
- [blocks_unpack_k_bits_bb_0_2, '0', virtual_sink_1_2, '0']
- [blocks_unpack_k_bits_bb_1_0, '0', blocks_matrix_interleaver_0_0, '0']
- [digital_additive_scrambler_xx_1, '0', epy_block_2_0, '0']
- [digital_constellation_decoder_cb_0_1, '0', digital_diff_decoder_bb_0_1, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_costas_loop_cc_0_1, '0', digital_constellation_decoder_cb_0_1, '0']
- [digital_costas_loop_cc_0_1, '0', qtgui_const_sink_x_0_1, '1']
- [digital_costas_loop_cc_0_1, '0', qtgui_eye_sink_x_0_1, '0']
- [digital_crc32_bb_1, '0', virtual_sink_1_2_0_1, '0']
- [digital_diff_decoder_bb_0_1, '0', digital_map_bb_0_0_1, '0']
- [digital_fll_band_edge_cc_0_0, '0', digital_symbol_sync_xx_0_1, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0_1, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [digital_map_bb_0_0_1, '0', blocks_unpack_k_bits_bb_0_2, '0']
- [digital_symbol_sync_xx_0_1, '0', virtual_sink_1_2_1, '0']
- [epy_block_0_0, '0', audio_sink_0_0_0, '0']
- [epy_block_2_0, '0', epy_block_0_0, '0']
- [fec_extended_decoder_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [filter_fft_rrc_filter_0_0_1, '0', analog_agc_xx_0_0, '0']
- [iio_pluto_source_0_0, '0', filter_fft_rrc_filter_0_0_1, '0']
- [virtual_source_0_0_0, '0', digital_linear_equalizer_0, '0']
- [virtual_source_0_0_0, '0', qtgui_const_sink_x_0_1, '0']
- [virtual_source_1_1, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [virtual_source_1_1_0, '0', blocks_unpack_k_bits_bb_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

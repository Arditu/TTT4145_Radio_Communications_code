options:
  parameters:
    author: ardiu
    generate_options: qt_gui
    id: RADIO_TX
    output_language: python
    title: TX
  states: {}

blocks:
- name: cma_algo
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '1'
    step_size: '.0001'
    type: cma
  states: {}
- name: encoder
  id: variable_cc_encoder_def
  parameters:
    framebits: '1280'
    k: '7'
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '320'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, 0.707-0.707j, +0.707+0.707j, -0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    maxoutbuf: '16384'
    samp_rate: samp_rate
  states: {}
- name: blocks_matrix_interleaver_0
  id: blocks_matrix_interleaver
  parameters:
    cols: '80'
    comment: |-
      Interleaving:
      Obtain a Memoryless Channel
    deint: 'False'
    rows: '32'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Bits to Byte
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_1_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: Byte to Bits
    k: '8'
  states: {}
- name: digital_additive_scrambler_xx_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '3'
    count: '0'
    len: '8'
    mask: '0x8A'
    reset_tag_key: '""'
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import opuslib

      class opus_encoder_stream(gr.basic_block):
          def __init__(self, sample_rate=48000, bitrate=64000):
              gr.basic_block.__init__(self, name='Opus Encoder Stream',
                                      in_sig=[np.float32], out_sig=[np.uint8])
              
              self.sample_rate = sample_rate
              self.frame_size = 960 
              self.enc = opuslib.Encoder(sample_rate, 1, 'audio')
              self.enc.bitrate = bitrate

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              if len(in0) < self.frame_size:
                  return 0
                  
              chunk = (in0[:self.frame_size] * 32767).astype(np.int16)
              
              try:
                  encoded_packet = self.enc.encode(chunk.tobytes(), self.frame_size)
                  packet_len = len(encoded_packet)
                  total_len = packet_len + 4 # 2 bytes sync + 2 bytes length
                  
                  if len(out) < total_len:
                      return 0
                      
                  # 1. Write Sync Word (0xAA 0x55)
                  out[0] = 0xAA
                  out[1] = 0x55
                  
                  # 2. Write 2-byte length header
                  out[2] = (packet_len >> 8) & 0xFF
                  out[3] = packet_len & 0xFF
                  
                  # 3. Write payload
                  out[4:total_len] = np.frombuffer(encoded_packet, dtype=np.uint8)
                  
                  self.consume(0, self.frame_size)
                  return total_len
                  
              except Exception as e:
                  print(f"Encode error: {e}")
                  self.consume(0, self.frame_size)
                  return 0
    bitrate: '64000'
    comment: |-
      Soruce Encoder: Opus
      Data rate 64 kbps
      Bit rate 65.6 kbps
    sample_rate: '48000'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class rsa_encrypt_byte(gr.sync_block):
          def __init__(self, public_e=7, n=253):
              gr.sync_block.__init__(
                  self,
                  name='RSA Encryption',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.e = public_e
              self.n = n

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # RSA Encryption: c = (m^e) % n
              # We use pow(m, e, n) for efficient modular exponentiation
              for i in range(len(in0)):
                  if in0[i] >= self.n:
                      # Value too high for this small modulus, clip it
                      val = self.n - 1
                  else:
                      val = in0[i]
                  
                  out[i] = pow(int(val), self.e, self.n)
                  
              return len(output_items[0])
    comment: |-
      Encryption:
      Rivest-Shamir-Adleman
    n: '253'
    public_e: '65537'
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: encoder
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: filter_fft_rrc_filter_0_1
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    comment: |-
      Symbol Rate: samp_rate/sps
      Alpha: excess_bw
      Num Taps: 11*sps
    decim: '1'
    gain: '1'
    ntaps: sps*25
    samp_rate: '300000'
    sym_rate: 300000/4
    type: ccc
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '200000'
    buffer_size: '16384'
    comment: Adalm Pluto Antenna (Tx)
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '868300000'
    samplerate: '300000'
    type: fc32
    uri: 'usb:'
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Transmitter
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '300000'
    fc: '0'
    fftsize: '2048'
    gui_hint: 12,0,10,20
    label1: Transmitted & Propagated
    label2: Received & Filtered
    name: Before and after filter Spectrum
    nconnections: '2'
    type: complex
    ymax: '-10'
  states: {}
- name: qtgui_time_sink_x_1_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: '"Inputed Voice"'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_signal
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: packed_data
  states: {}
- name: virtual_sink_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: encoded_data
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: mod_signal
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: filtered_signal
  states: {}
- name: virtual_source_4_0
  id: virtual_source
  parameters:
    stream_id: packed_data
  states: {}
- name: virtual_source_4_0_0
  id: virtual_source
  parameters:
    stream_id: encoded_data
  states: {}

connections:
- [audio_source_0, '0', epy_block_1_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_1_1_0_0_0, '0']
- [blocks_matrix_interleaver_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', virtual_sink_0_0_0_0_1, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_tagged_stream_mux_0_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_unpack_k_bits_bb_1_0_0, '0', fec_extended_encoder_0, '0']
- [digital_additive_scrambler_xx_0, '0', blocks_unpack_k_bits_bb_1_0_0, '0']
- [digital_constellation_modulator_0_0, '0', filter_fft_rrc_filter_0_1, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_0, '0', virtual_sink_3, '0']
- [digital_crc32_bb_0_0, '0', blocks_tagged_stream_mux_0_0_0, '1']
- [digital_crc32_bb_0_0, '0', digital_protocol_formatter_bb_0_0, '0']
- [digital_protocol_formatter_bb_0_0, '0', blocks_tagged_stream_mux_0_0_0, '0']
- [epy_block_1_0, '0', epy_block_2, '0']
- [epy_block_2, '0', digital_additive_scrambler_xx_0, '0']
- [fec_extended_encoder_0, '0', blocks_matrix_interleaver_0, '0']
- [filter_fft_rrc_filter_0_1, '0', iio_pluto_sink_0_0, '0']
- [filter_fft_rrc_filter_0_1, '0', virtual_sink_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_4_0, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_4_0, '0', virtual_sink_2_0, '0']
- [virtual_source_4_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
